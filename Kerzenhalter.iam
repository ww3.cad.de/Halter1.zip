# Autodesk Inventor assembly: Kerzenhalter
## iProperties
Created: 2005-10
Part Number: Kerzenhalter
Document SubType Name: Assembly
Designer: Bernhard Fetzer
Author: Bernhard Fetzer
