# Autodesk Inventor part: teil2
## iProperties
Created: 2005-10
Part Number: teil2
Document SubType Name: Modeling
Designer: Bernhard Fetzer
Author: Bernhard Fetzer
## Feature names
1. Sweeping2
